Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Lighting_Other_DGA-s-r-l_COMETA-NGL.ifc
Time: 2019-05-15T10:00:09
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: COMETA NGL
ePset_BIMobjectScript - LED colour: 1 - 5000K; Type: Floor-mounted; LOD: 300; Length with 30 mm step: 0.0003
ePset_BIMobject_BO - ProductName (BO_prodinfo): COMETA NGL; SKU (BO_prodsku): cometa_ngl; ManufacturName (BO_Manufac): DGA; BrandUrl (BO_brandurl): http://www.dga.it/en; ProductFamily (BO_prodfam): Lighting; ProductGroup (BO_prodgroup): LED; ManufacturCountry (BO_mancont): Italy; DesignCountry (BO_designcont): Italy; PublishDate (BO_publisdat): 12/20/2018; EditionNumber (BO_edinum): 1; Width (BO_width): 4.5; Height (BO_height): 4.5; Depth (BO_depth): 107; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/dga/product/cometa_ngl; ProductDataUrl (BO_prodaturl): bimobject.com/dga/product/cometa_ngl; ProductUrl (BO_producturl): http://www.dga.it/en/products/cometa-ngl.php; TechnicalDescription (BO_techcert): http://www.dga.it/file_public/product/26/dga_cometa-ngl_catalogue.pdf; MaterialMain (BO_mainmat): Plastic; BimObjectMainCategory (BO_bomaincat): Lighting; BimObjectMainCategoryCode (BO_bomaincat_code): lighting; BimObjectCategory (BO_bocat): Other; BimObjectCategoryCode (BO_bocat_code): lighting-other; IfcClassification (BO_ifcclas): Light Fixture; UnspcCode (BO_unspc): 3911; Uniclass14Code (BO_uniclass_1_4_code): JV5; Uniclass14Description (BO_uniclass_1_4_desc): General lighting; Uniclass20Code (BO_uniclass_2_0_code): SS-70-80; Uniclass20Description (BO_uniclass_2_0_desc): Lighting Systems; Uniclass2015Code (BO_uniclass2015_code): EF_70_80; Uniclass2015Description (BO_uniclass2015_desc): Lighting; NBSReference (BO_nbs_ref): 70-80-33; NBSReferenceDescription (BO_nbs_desc): General Lighting Systems; OmniClassCode (BO_omniclass_code): 23-35 47 11; OmniClassDescription (BO_omniclass_name): Lighting Fixtures; MasterFormat2014Code (BO_masterformat2014_code): 26 50 00; MasterFormat2014Description (BO_masterformat2014_name): Lighting; RegionEurope (BO_europe): AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA; RegionNorthAmerica (BO_northamerica): AG, AI, AW, BB, BL, BM, BQ, BS, BZ, CA, CR, CU, CW, DM, DO, GD, GL, GP, GT, HN, HT, JM, KN, KY, LC, MF, MQ, MS, MX, NI, PA, PM, PR, SV, SX, TC, TT, US, VC, VG, VI; RegionSouthAmerica (BO_southamerica): AR, BO, BR, CL, CO, EC, FK, GF, GY, PE, PY, SR, UY, VE; RegionMiddleEast (BO_middleeast): AE, AF, BH, EG, IL, IQ, IR, JO, KW, LB, OM, PS, QA, SA, SY, TR, YE; RegionAsia (BO_asia): AM, AZ, BD, BN, BT, CC, CN, CX, GE, HK, ID, IN, IO, JP, KG, KH, KP, KR, KZ, LA, LK, MM, MN, MO, MV, MY, NP, PH, PK, SG, TH, TJ, TM, TW, UZ, VN; RegionOceania (BO_oceania): AS, AU, CK, FJ, FM, GU, KI, MH, MP, NC, NF, NR, NU, NZ, PF, PG, PN, PW, SB, TK, TL, TO, TV, UM, WF, WS, VU; RegionAfrica (BO_africa): AO, BF, BI, BJ, BW, CD, CF, CG, CI, CM, CV, DJ, DZ, EH, ER, ET, GA, GH, GM, GN, GQ, GW, KE, KM, LR, LS, LY, MA, MG, ML, MR, MU, MW, MZ, NA, NE, NG, RE, RW, SC, SD, SH, SL, SN, SO, SS, ST, SZ, TD, TG, TN, TZ, UG, YT, ZA, ZM, ZW; RegionAntarctica (BO_antarctica): AQ, BV, GS, HM, TF
